# Keil uVision project NonSecure.uvprojx, settings and files
target NonSecure (6150000::V6.15::ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: NonSecure +hex
  c flags: OneElfS=1 v6Lang=5
  c define: DEBUG_PORT=UART0_NS
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M2351\Include;..\..\..\Library\StdDriver\inc;..\NonSecure;.\SSD1327;.\SSD1327_Fonts;.\WiFi
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\Objects\NonSecure.sct
  group CMSIS
    ../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
    ../../../Library/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
  group Library
    ../../../Library/StdDriver/src/: gpio.c retarget.c
  group Include
    ./SSD1327_Fonts/: fonts.h
    ./SSD1327/: DEV_Config.h OLED_Driver.h OLED_GUI.h
    ./WiFi/: wifi.h
    ../Secure/lib/: nsclib.o
    ./: cssd_lib.h
    ../../../Library/Device/Nuvoton/M2351/Include/: NuMicro.h
  group SSD1327
    ./SSD1327/: DEV_Config.c OLED_Driver.c OLED_GUI.c
  group SSD1327_Fonts
    ./SSD1327_Fonts/: font8.c font12.c font16.c font20.c font24.c
  group WiFi
    ./WiFi/: wifi.c
  group User
    ./: main_ns.c
software components: PSA:Crypto:mbed TLS 2.24.0
