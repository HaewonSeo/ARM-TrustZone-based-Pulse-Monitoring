# Keil uVision project Secure.uvprojx, settings and files
target Secure (6150000::V6.15::ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: Secure
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3
  c define: DEBUG_PORT = UART0_NS
  c include: ..\Secure;.\Crypto;.\MAX30102;..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M2351\Include;..\..\..\Library\StdDriver\inc;..\..\..\ThirdParty\mbedTLS\include;..\..\..\ThirdParty\mbedTLS\include\mbedtls
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\Objects\Secure.sct
  link misc: --import-cmse-lib-out .\lib\nsclib.o
  group CMSIS
    ../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
    ../../../Library/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
  group Library
    ../../../Library/StdDriver/src/: clk.c crypto.c fmc.c gpio.c i2c.c retarget.c spi.c sys.c uart.c
  group Include
    ./: nsc.h
    ./MAX30102/: MAX30102.h
    ./Crypto/: M2351_crypto.h
  group MAX30102
    ./MAX30102/: MAX30102.c
  group Crypto
    ./Crypto/: M2351_crypto.c
  group User
    ./: nsc.c partition_M2351.h mbedTLS_config.h main.c
