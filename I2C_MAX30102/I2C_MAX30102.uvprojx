# Keil uVision project I2C_MAX30102.uvprojx, settings and files
target I2C_MAX30102 (6150000::V6.15::ARMCLANG)
  device: M2351KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: I2C_MAX30102
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3
  c define: DEBUG_PORT = UART0_NS
  c include: ..\I2C_MAX30102;..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\M2351\Include;..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\Objects\I2C_MAX30102.sct
  link misc: --import-cmse-lib-out .\lib\nsclib.o
  group CMSIS
    ../../Library/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
    ../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
  group Library
    ../../Library/StdDriver/src/: clk.c i2c.c retarget.c sys.c uart.c gpio.c
  group User
    ./: i2c_max30102.c main.c partition_M2351.h i2c_max30102.h nsc.c nsc.h
software components: PSA:Crypto:mbed TLS 2.24.0
